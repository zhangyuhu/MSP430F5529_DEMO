# IAR project DEMO.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: src; src\Demo; src\HAL; driverlib; driverlib\inc; driverlib\deprecated\IAR; F5xx_F6xx_Core_Lib; GRAPH; GRAPH\graphdriver; GRAPH\grlib; sdCard; sdCard\FatFs
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.c
  group driverlib
    driverlib/: adc12_a.c adc12_a.h gpio.c gpio.h ref.c ref.h timer_a.c timer_a.h
    driverlib/inc/: hw_memmap.h hw_regaccess.h hw_types.h version.h
    driverlib/deprecated/IAR/: msp430f5xx_6xxgeneric.h
  group F5xx_F6xx_Core_Lib
    F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h HAL_MACROS.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
  group GRAPH
    GRAPH/grlib/: circle.c context.c grlib.h image.c line.c rectangle.c string.c
    GRAPH/fonts/: fontcm16b.c fontcm28b.c fontfixed6x8.c
    GRAPH/graphdriver/: Template_Driver.c Template_Driver.h
  group sdCard
    sdCard/FatFs/: diskio.h ff.c ff.h ffconf.h integer.h mmc.c mmc.h
    sdCard/: HAL_SDCard.c HAL_SDCard.h wavType.c wavType.h
    sdCard/FatFs/option/: syscall.c
  group src
    src/HAL/: DAC.c DAC.h HCI.c HCI.h Interrupt.c Interrupt.h softFIFO.c softFIFO.h softFilter.c softFilter.h UserGraphic.c UserGraphic.h
    src/: Demo_OS.c Demo_OS.h global.c global.h
    src/Demo/: Music_Display.c Music_Display.h Record.c Record.h
